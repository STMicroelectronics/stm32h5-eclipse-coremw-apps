# IAR project Ux_Device_HID_Standalone.ewp, settings and files
configuration Ux_Device_HID_Standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USBPD_PORT_COUNT=1; _SNK; UX_INCLUDE_USER_DEFINE_FILE; USBPDCORE_LIB_NO_PD; USE_HAL_DRIVER; STM32H563xx
  ICCARM.CCIncludePath2: ../USBX/App; ../USBX/Target; ../USBPD/App; ../USBPD/Target; ../Core/Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../../Middlewares/ST/usbx/common/core/inc; ../../../../../../Middlewares/ST/usbx/ports/generic/inc; ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc; ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32H5XX/inc; ../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers; ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/inc; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32H5xx_Nucleo; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Ux_Device_HID_Standalone.hex
  ILINK.IlinkOutputFile: Ux_Device_HID_Standalone.out
  ILINK.IlinkIcfFile: stm32h563xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h563xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c
  group Application/User/USBPD/App
    ../USBPD/App/: usbpd.c usbpd_dpm_core.c usbpd_dpm_user.c usbpd_pwr_if.c usbpd_usb_if.c
  group Application/User/USBX/App
    ../USBX/App/: app_usbx_device.c ux_device_descriptors.c ux_device_mouse.c
  group Doc
    ../: README.md
  group Drivers/BSP/NUCLEO-H563ZI
    ../../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c stm32h5xx_nucleo_usbpd_pwr.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_adc.c stm32h5xx_hal_adc_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_icache.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_ll_dma.c stm32h5xx_ll_exti.c stm32h5xx_ll_gpio.c stm32h5xx_ll_rcc.c stm32h5xx_ll_ucpd.c stm32h5xx_ll_usb.c stm32h5xx_ll_utils.c
  group Middlewares/USBPD
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32H5XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_NOPD_CM33_wc32.a
  group Middlewares/USBX/Core System
    ../../../../../../Middlewares/ST/usbx/common/core/src/: ux_system_error_handler.c ux_system_initialize.c ux_system_tasks_run.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group Middlewares/USBX/UX Device Class HID
    ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_hid_activate.c ux_device_class_hid_control_request.c ux_device_class_hid_deactivate.c ux_device_class_hid_descriptor_send.c ux_device_class_hid_entry.c ux_device_class_hid_event_get.c ux_device_class_hid_event_set.c ux_device_class_hid_initialize.c ux_device_class_hid_read_run.c ux_device_class_hid_receiver_event_free.c ux_device_class_hid_receiver_event_get.c ux_device_class_hid_receiver_initialize.c ux_device_class_hid_receiver_tasks_run.c ux_device_class_hid_receiver_uninitialize.c ux_device_class_hid_report_get.c ux_device_class_hid_report_set.c ux_device_class_hid_tasks_run.c ux_device_class_hid_uninitialize.c
  group Middlewares/USBX/UX Device Controllers
    ../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c
  group Middlewares/USBX/UX Device CoreStack
    ../../../../../../Middlewares/ST/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_tasks_run.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_uninitialize.c
